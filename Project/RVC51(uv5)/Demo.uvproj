# Keil uVision project Demo.uvproj, settings and files
target Demo_Debug (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\App;..\..\Bsp;..\..\Ultrasound;..\..\Lcd1602;..\..\RF_transceiving;..\..\Nixie_tube;..\..\NRF24L01;..\..\Bogie
  link misc: REMOVEUNUSED
  group STARTUP
    ../../App/: STARTUP.A51
  group CMSIS
    ../../App/: REG52.H
  group Bsp
    ../../Bsp/: bsp.c bsp_exti.c bsp_time.c bsp_uart.c
  group RF
    ../../RF_transceiving/: rf_receive.c rf_send.c
  group Nixie_Tube
    ../../Nixie_tube/: nixie_drv.c
  group LCD1602
    ../../Lcd1602/: lcd1602_drv.c
  group NRF24L01
    ../../NRF24L01/: nrf24l01_drv.c
  group UT_Wave
    ../../Ultrasound/: ultrasound_wave.c
  group Bogie
    ../../Bogie/: car_drv.c car_avoid.c car_remote.c car_tracking.c
  group User
    ../../App/: main.c
  group Doc
    ../../Doc/: ReadMe.txt
